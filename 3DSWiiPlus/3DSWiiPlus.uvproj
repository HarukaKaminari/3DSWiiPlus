# Keil uVision project 3DSWiiPlus.uvproj, settings and files
target 3DSWiiPlus (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 3DSWiiPlus +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: LCM_DRIVER_IST3932
  group Common
    ./: typedef.h FontText.h STC15W4K.h
  group Dependencies
    ./: Utility.c Utility.h Uart.c Uart.h I2C.c I2C.h IAP.c IAP.h PWM.c PWM.h SPI.c SPI.h Timer.c Timer.h
  group Devices
    ./: WiiClassicController.c WiiClassicController.h LCM12864.c LCM12864.h CTRInterface.c CTRInterface.h SaveData.c SaveData.h NRF24L01.c NRF24L01.h Controller.c Controller.h UC1701X.c UC1701X.h IST3932.c IST3932.h SSD1306.c SSD1306.h
  group Modules
    ./: main.c main.h ModuleConnect.c ModuleConnect.h ModuleCountdown.c ModuleCountdown.h ModuleGeneric.c ModuleGeneric.h ModuleConfigMenu.c ModuleConfigMenu.h ModuleKeyMapping.c ModuleKeyMapping.h ModuleAnalogMapping.c ModuleAnalogMapping.h ModuleAnalogCalibration.c ModuleAnalogCalibration.h ModuleTurboSetting.c ModuleTurboSetting.h
